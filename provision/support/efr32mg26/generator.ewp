# IAR project generator.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: efr32mg26b410f3200im48 SiliconLaboratories efr32mg26b410f3200im48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CHIP_CONFIG_SHA256_CONTEXT_SIZE=256; CHIP_CRYPTO_PLATFORM=1; CHIP_LOG_FILTERING=1; CHIP_PLATFORM_CONFIG_INCLUDE=<platform/silabs/CHIPPlatformConfig.h>; CHIP_SYSTEM_CONFIG_USE_SOCKETS=1; OTA_ENCRYPTION_ENABLE=1; SILABS_PROVISION_PROTOCOL_V1=0; SL_PROVISION_CHANNEL_ENABLED=1; SL_PROVISION_GENERATOR=1; EFR32MG26B410F3200IM48=1; SL_APP_PROPERTIES=1; configNUM_SDK_THREAD_LOCAL_STORAGE_POINTERS=2; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; RTT_USE_ASM=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; ..\..\generator; ..\..\..\examples; ..\..\..\examples\platform\silabs; ..\..\..\src; ..\..\..\src\include; ..\..\..\zzz_generated\app-common; ..\..\..\third_party\nlassert\repo\include; ..\..\..\third_party\nlio\repo\include; ..\..\..\third_party\silabs\gecko_sdk\platform\bootloader; ..\..\..\third_party\silabs\gecko_sdk\protocol\bluetooth\config; ..\..\..\..\..\stash\gsdk\platform\Device\SiliconLabs\EFR32MG26\Include; ..\..\..\..\..\stash\gsdk\platform\common\inc; ..\..\..\..\..\stash\gsdk\platform\CMSIS\Core\Include; ..\..\..\..\..\stash\gsdk\platform\CMSIS\RTOS2\Include; ..\..\..\..\..\stash\gsdk\platform\service\device_init\inc; ..\..\..\..\..\stash\gsdk\platform\emdrv\common\inc; ..\..\..\..\..\stash\gsdk\platform\emlib\inc; ..\..\..\..\..\stash\gsdk\util\third_party\freertos\cmsis\Include; ..\..\..\..\..\stash\gsdk\util\third_party\freertos\kernel\include; ..\..\..\..\..\stash\gsdk\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\..\..\stash\gsdk\platform\service\iostream\inc; ..\..\..\..\..\stash\gsdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\..\..\stash\gsdk\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\..\..\stash\gsdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\..\..\stash\gsdk\util\third_party\mbedtls\include; ..\..\..\..\..\stash\gsdk\util\third_party\mbedtls\library; ..\..\..\..\..\stash\gsdk\platform\emdrv\nvm3\inc; ..\..\..\..\..\stash\gsdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\..\..\stash\gsdk\platform\security\sl_component\se_manager\inc; ..\..\..\..\..\stash\gsdk\platform\security\sl_component\se_manager\src; ..\..\..\..\..\stash\gsdk\util\third_party\segger\systemview\SEGGER; ..\..\..\..\..\stash\gsdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\..\..\stash\gsdk\platform\common\toolchain\inc; ..\..\..\..\..\stash\gsdk\platform\service\system\inc; config; autogen; ..\..\..\third_party\silabs\simplicity_sdk\platform\bootloader; ..\..\..\third_party\silabs\simplicity_sdk\protocol\bluetooth\config; ..\..\..\..\..\gsdk\platform\Device\SiliconLabs\EFR32MG26\Include; ..\..\..\..\..\gsdk\platform\common\inc; ..\..\..\..\..\gsdk\platform\CMSIS\Core\Include; ..\..\..\..\..\gsdk\platform\CMSIS\RTOS2\Include; ..\..\..\..\..\gsdk\platform\service\device_init\inc; ..\..\..\..\..\gsdk\platform\emdrv\common\inc; ..\..\..\..\..\gsdk\platform\emlib\inc; ..\..\..\..\..\gsdk\util\third_party\freertos\cmsis\Include; ..\..\..\..\..\gsdk\util\third_party\freertos\kernel\include; ..\..\..\..\..\gsdk\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\..\..\gsdk\platform\service\iostream\inc; ..\..\..\..\..\gsdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\..\..\gsdk\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\..\..\gsdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\..\..\gsdk\util\third_party\mbedtls\include; ..\..\..\..\..\gsdk\util\third_party\mbedtls\library; ..\..\..\..\..\gsdk\platform\emdrv\nvm3\inc; ..\..\..\..\..\gsdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\..\..\gsdk\platform\security\sl_component\se_manager\inc; ..\..\..\..\..\gsdk\platform\security\sl_component\se_manager\src; ..\..\..\..\..\gsdk\util\third_party\segger\systemview\SEGGER; ..\..\..\..\..\gsdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\..\..\gsdk\platform\common\toolchain\inc; ..\..\..\..\..\gsdk\platform\service\system\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generator.s37
  ILINK.IlinkOutputFile: generator.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: generator.ipcf
