# IAR project generator.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG24A010F1024IM48 SiliconLaboratories EFR32MG24A010F1024IM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CHIP_CONFIG_SHA256_CONTEXT_SIZE=256; CHIP_CRYPTO_PLATFORM=1; CHIP_LOG_FILTERING=1; CHIP_PLATFORM_CONFIG_INCLUDE=<platform/silabs/CHIPPlatformConfig.h>; CHIP_SYSTEM_CONFIG_USE_SOCKETS=1; OTA_ENCRYPTION_ENABLE=1; SILABS_PROVISION_PROTOCOL_V1=0; SL_PROVISION_CHANNEL_ENABLED=1; SL_PROVISION_GENERATOR=1; EFR32MG24A010F1024IM48=1; SL_APP_PROPERTIES=1; configNUM_SDK_THREAD_LOCAL_STORAGE_POINTERS=2; SL_COMPONENT_CATALOG_PRESENT=1; CMSIS_NVIC_VIRTUAL=1; CMSIS_NVIC_VIRTUAL_HEADER_FILE="cmsis_nvic_virtual.h"; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; SL_MEMORY_POOL_LIGHT=1; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; RTT_USE_ASM=0; SL_CODE_COMPONENT_CORE=core
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; ..\..\..\third_party\silabs\gecko_sdk\platform\bootloader; ..\..\..\third_party\silabs\gecko_sdk\protocol\bluetooth\config; ..\..\..\third_party\silabs\gecko_sdk\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\third_party\silabs\gecko_sdk\platform\common\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\CMSIS\Core\Include; ..\..\..\third_party\silabs\gecko_sdk\platform\CMSIS\RTOS2\Include; ..\..\..\third_party\silabs\gecko_sdk\platform\service\device_init\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\emdrv\common\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\emlib\inc; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\freertos\cmsis\Include; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\freertos\kernel\include; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\third_party\silabs\gecko_sdk\platform\service\iostream\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\mbedtls\include; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\mbedtls\library; ..\..\..\third_party\silabs\gecko_sdk\platform\emdrv\nvm3\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\peripheral\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\se_manager\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\security\sl_component\se_manager\src; ..\..\..\third_party\silabs\gecko_sdk\util\third_party\segger\systemview\SEGGER; ..\..\..\third_party\silabs\gecko_sdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\third_party\silabs\gecko_sdk\platform\common\toolchain\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\service\system\inc; ..\..\..\third_party\silabs\gecko_sdk\platform\service\sleeptimer\inc; config; autogen; ..\..\generator; ..\..\..\examples; ..\..\..\examples\platform\silabs; ..\..\..\src; ..\..\..\src\include; ..\..\..\zzz_generated\app-common; ..\..\..\third_party\nlassert\repo\include; ..\..\..\third_party\nlio\repo\include; ..\..\..\third_party\silabs\simplicity_sdk\platform\bootloader; ..\..\..\third_party\silabs\simplicity_sdk\protocol\bluetooth\config; ..\..\..\third_party\silabs\simplicity_sdk\platform\Device\SiliconLabs\EFR32MG24\Include; ..\..\..\third_party\silabs\simplicity_sdk\platform\common\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\CMSIS\Core\Include; ..\..\..\third_party\silabs\simplicity_sdk\platform\CMSIS\RTOS2\Include; ..\..\..\third_party\silabs\simplicity_sdk\platform\service\device_init\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\emdrv\common\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\emlib\inc; ..\..\..\third_party\silabs\simplicity_sdk\util\third_party\freertos\cmsis\Include; ..\..\..\third_party\silabs\simplicity_sdk\util\third_party\freertos\kernel\include; ..\..\..\third_party\silabs\simplicity_sdk\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\third_party\silabs\simplicity_sdk\platform\service\interrupt_manager\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\service\interrupt_manager\inc\arm; ..\..\..\third_party\silabs\simplicity_sdk\platform\service\iostream\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\third_party\silabs\simplicity_sdk\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\third_party\silabs\simplicity_sdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\third_party\silabs\simplicity_sdk\util\third_party\mbedtls\include; ..\..\..\third_party\silabs\simplicity_sdk\util\third_party\mbedtls\library; ..\..\..\third_party\silabs\simplicity_sdk\platform\service\memory_manager\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\service\memory_manager\src; ..\..\..\third_party\silabs\simplicity_sdk\platform\emdrv\nvm3\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\security\sl_component\se_manager\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\security\sl_component\se_manager\src; ..\..\..\third_party\silabs\simplicity_sdk\util\third_party\segger\systemview\SEGGER; ..\..\..\third_party\silabs\simplicity_sdk\platform\common\toolchain\inc; ..\..\..\third_party\silabs\simplicity_sdk\platform\service\system\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generator.s37
  ILINK.IlinkOutputFile: generator.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: generator.ipcf
