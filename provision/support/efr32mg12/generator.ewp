# IAR project generator.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG12P232F512GM68 SiliconLaboratories EFR32MG12P232F512GM68
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CHIP_CONFIG_SHA256_CONTEXT_SIZE=256; CHIP_CRYPTO_PLATFORM=1; CHIP_LOG_FILTERING=1; CHIP_PLATFORM_CONFIG_INCLUDE=<platform/silabs/CHIPPlatformConfig.h>; CHIP_SYSTEM_CONFIG_USE_SOCKETS=1; OTA_ENCRYPTION_ENABLE=1; SILABS_PROVISION_PROTOCOL_V1=0; SL_PROVISION_CHANNEL_ENABLED=1; SL_PROVISION_GENERATOR=1; EFR32MG12P232F512GM68=1; SL_APP_PROPERTIES=1; configNUM_SDK_THREAD_LOCAL_STORAGE_POINTERS=2; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; RTT_USE_ASM=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; ..\..\generator; ..\..\..\examples; ..\..\..\examples\platform\silabs; ..\..\..\src; ..\..\..\src\include; ..\..\..\zzz_generated\app-common; ..\..\..\third_party\nlassert\repo\include; ..\..\..\third_party\nlio\repo\include; ..\..\..\third_party\silabs\simplicity_sdk\platform\bootloader; ..\..\..\third_party\silabs\simplicity_sdk\protocol\bluetooth\config; ..\..\..\..\..\..\git\gsdk\platform\Device\SiliconLabs\EFR32MG12P\Include; ..\..\..\..\..\..\git\gsdk\platform\common\inc; ..\..\..\..\..\..\git\gsdk\platform\CMSIS\Core\Include; ..\..\..\..\..\..\git\gsdk\platform\CMSIS\RTOS2\Include; ..\..\..\..\..\..\git\gsdk\platform\service\device_init\inc; ..\..\..\..\..\..\git\gsdk\platform\emdrv\common\inc; ..\..\..\..\..\..\git\gsdk\platform\emlib\inc; ..\..\..\..\..\..\git\gsdk\util\third_party\freertos\cmsis\Include; ..\..\..\..\..\..\git\gsdk\util\third_party\freertos\kernel\include; ..\..\..\..\..\..\git\gsdk\util\third_party\freertos\kernel\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\git\gsdk\platform\service\iostream\inc; ..\..\..\..\..\..\git\gsdk\platform\security\sl_component\sl_mbedtls_support\config; ..\..\..\..\..\..\git\gsdk\platform\security\sl_component\sl_mbedtls_support\config\preset; ..\..\..\..\..\..\git\gsdk\platform\security\sl_component\sl_mbedtls_support\inc; ..\..\..\..\..\..\git\gsdk\util\third_party\mbedtls\include; ..\..\..\..\..\..\git\gsdk\util\third_party\mbedtls\library; ..\..\..\..\..\..\git\gsdk\platform\emdrv\nvm3\inc; ..\..\..\..\..\..\git\gsdk\platform\security\sl_component\sl_psa_driver\inc; ..\..\..\..\..\..\git\gsdk\util\third_party\segger\systemview\SEGGER; ..\..\..\..\..\..\git\gsdk\util\silicon_labs\silabs_core\memory_manager; ..\..\..\..\..\..\git\gsdk\platform\common\toolchain\inc; ..\..\..\..\..\..\git\gsdk\platform\service\system\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generator.s37
  ILINK.IlinkOutputFile: generator.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: generator.ipcf
